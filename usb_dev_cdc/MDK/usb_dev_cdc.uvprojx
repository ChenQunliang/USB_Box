# Keil uVision project usb_dev_cdc.uvprojx, settings and files
target usb_dev_cdc_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_dev_cdc +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,_PLATFORM_ARM_
  c include: ../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../drivers/cmsis/Include;../../drivers/hc32_ll_driver/inc;../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../midwares/hc32/usb;../../midwares/hc32/usb/usb_device_lib/device_core;../../midwares/hc32/usb/usb_device_lib/device_class/single_cdc;..\cm_backtrace;..\MultMenu;..\MultMenu\application;..\MultMenu\disp;..\MultMenu\menu;..\u8g2Drive;..\u8g2Drive\u8g2Lib;..\u8g2Drive\u8g2Lib\inc;..\u8g2Drive\u8g2Lib\src;..\src;..\headers
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x60000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group driver
    ../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_crc.c hc32_ll_fcg.c hc32_ll_tmr0.c hc32_ll_i2c.c hc32_ll_fcm.c hc32_ll_tmra.c hc32_ll_qspi.c
  group cmsis
    ../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ./: startup_hc32f460.s
  group ev_hc32f460_lqfp100_v2
    ../../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group src
    ../src/: main.c EncodTimA.c tv5725.c v_i2c.c si5351.c flash.c
  group MULTMENU/MENU
    ../MultMenu/menu/: image.c menu.c menuConfig.c parameter.c text.c wave.c
  group MULTMENU/DISP
    ../MultMenu/disp/: dispDirver.c
  group MULTMENU/APPLICATION
    ../MultMenu/application/: AirPlane.c application.c tv5725_callbacks.c DinoGame.c
  group SRC/U8G2DRIVE/U8G2LIB/SRC
    ../u8g2Drive/u8g2Lib/src/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group SRC/U8G2DRIVE
    ../u8g2Drive/: hc32_u8g2.c
  group cm_backtrace
    ../cm_backtrace/: cm_backtrace.c
    ../cm_backtrace/fault_handler/keil/: cmb_fault.S
target usb_dev_cdc_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: usb_dev_cdc +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../../../../../midwares/hc32/usb;../../../../../../midwares/hc32/usb/usb_device_lib/device_core;../../../../../../midwares/hc32/usb/usb_device_lib/device_class/single_cdc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
